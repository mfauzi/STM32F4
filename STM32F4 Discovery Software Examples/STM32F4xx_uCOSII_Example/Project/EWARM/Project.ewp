# IAR project Project.ewp, settings and files
configuration Discover-More (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\CPU\ST\STM32\STM32F4xx_StdPeriph_Driver\inc; ..\..\CPU\ST\STM32\STM32F4xx; ..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\EWARM; ..\..\uCOS-II\Source; ..\..\CPU\ST\STM32\inc; ..\..\uC-CPU; ..\..\uC-CPU\ARM-Cortex-M3\EWARM; ..\..\uC-LIB; ..\Common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c system_stm32f4xx.c
    ../inc/: app_cfg.h os_cfg.h
    ./: startup_stm32f4xx.s
  group BSP
    ../src/: bsp.c bsp_int.c bsp_periph.c
    ../inc/: bsp.h
    ../Common/: stm32f4_discovery.c
  group FWL
    ../../CPU/ST/STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group Readme
    ../: Readme.txt
  group uCOS/CPU
    ../../uC-CPU/ARM-Cortex-M3/EWARM/: cpu.h cpu_a.asm cpu_c.c
    ../../uC-CPU/: cpu_def.h
  group uCOS/Port
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/EWARM/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
