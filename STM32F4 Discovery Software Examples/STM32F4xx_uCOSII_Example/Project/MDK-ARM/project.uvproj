# Keil uVision project project.uvproj, settings and files
target Discover-More (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=2 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: .;..\inc;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\MDK-ARM;..\..\uCOS-II\Source;..\..\uC-CPU;..\..\uC-CPU\ARM-Cortex-M3\MDK-ARM;..\..\uC-LIB;..\Common;..\..\CPU\ST\STM32\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../src/: app.c system_stm32f4xx.c
    ../inc/: app_cfg.h os_cfg.h
    ./: startup_stm32f4xx.s
  group BSP
    ../inc/: bsp.h
    ../src/: bsp.c bsp_int.c bsp_periph.c
    ../Common/: stm32f4_discovery.c
  group FWL
    ../../CPU/ST/STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_syscfg.c
  group uC-CPU
    ../../uC-CPU/ARM-Cortex-M3/MDK-ARM/: cpu.h cpu_a.asm cpu_c.c
    ../../uC-CPU/: cpu_def.h
  group uC-OS-II/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/MDK-ARM/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group readme
    ../: Readme.txt
